## config/boards/shields/pragmatic36/Kconfig.defconfig
```kconfig
if SHIELD_PRAGMATIC36

  config ZMK_KEYBOARD_NAME 
    default "Pragmatic36"

endif
```
